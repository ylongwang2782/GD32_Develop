# Keil uVision project WirelessHarnessTest.uvprojx, settings and files
target GD32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F470VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IROM(0x08000000,0x0300000) IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WirelessHarnessTest +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\CMSIS\GD\GD32F4xx\Include;..\CMSIS;..\GD32F4xx_Peripherals\Include;..\Utilities;..\..\GD32_Template_1;..\Application\include;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../CMSIS/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../GD32F4xx_Peripherals/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32Fxx_START
    ../GD32F4xx_START/: gd32f470v_start.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group customer
    ../Application/source/: receive_send_config.c node_period_config.c sys_config.c global_config.c pin_period_config.c peripheral_config.c protocol.c i2c.c xl9555.c adc_config.c
